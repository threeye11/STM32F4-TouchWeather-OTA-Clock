# Keil uVision project Project.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08008000,0x00078000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,
  c include: ..\..\app;..\..\app\font;..\..\app\image;..\..\app\page;..\..\board;..\..\bsp;..\..\libraries\CMSIS\Include;..\..\libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\module;..\..\bsp\uart;..\..\bsp\LCD;..\..\bsp\TOUCH;..\..\bsp\KEY;..\..\bsp\ESP32;..\..\bsp\DHT11;..\..\bsp\RTC;..\..\bsp\ADC;..\..\Third_Lib\FreeRTOS;..\..\Third_Lib\FreeRTOS\inc;..\..\Third_Lib\FreeRTOS\src;..\..\Third_Lib\FreeRTOS\port;..\..\Third_Lib\Middlewares\LVGL_8.3.10\GUI;..\..\Third_Lib\Middlewares\LVGL_8.3.10\GUI\lvgl;..\..\Third_Lib\Middlewares\LVGL_8.3.10\GUI\lvgl\src;..\..\Third_Lib\Middlewares\LVGL_8.3.10\GUI\lvgl\examples\porting;..\..\bsp\FLASH;..\..\app\ota
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x78000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group APP
    ../../libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../../app/: main.c weather.c mytasks.c
    ../../module/: stm32f4xx_it.c
    ../../app/ota/: ota_flags.c ota_selftest.c ota_startup.c md5.c ota_http.c
  group APP/Font
    ../../app/font/: my_chinese_font_16.c my_chinese_font_32.c my_chinese_font_48.c
  group APP/Image
    ../../app/image/: image.c lv_logo.c lv_battery.c lv_Clock.c lv_Network.c lv_Ota.c lv_Weather.c lv_Wifi.c lv_Wifioff.c lv_cloud.c lv_Rain.c lv_sun.c
  group APP/Page
    ../../app/page/: lv_app.c
  group STARTUP
    ../../libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40xx.s
  group BSP
    ../../bsp/FLASH/: w25q64.c
    ../../bsp/uart/: bsp_uart.c
    ../../bsp/LCD/: SPI.c LCD.c
    ../../bsp/TOUCH/: CTPIIC.c FT6336.c tp_cal.c
    ../../bsp/KEY/: KEY.c
    ../../bsp/ESP32/: ESP32.c
    ../../bsp/DHT11/: dht11.c
    ../../bsp/RTC/: rtc.c
    ../../bsp/ADC/: battery.c
  group Board
    ../../board/: board.c
  group Driver
    ../../libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group FreeRTOS/inc
    ../../Third_Lib/FreeRTOS/: FreeRTOSConfig.h
    ../../Third_Lib/FreeRTOS/inc/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group FreeRTOS/src
    ../../Third_Lib/FreeRTOS/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS/port
    ../../Third_Lib/FreeRTOS/port/: heap_4.c port.c
  group Middlewares/lvgl/example/porting
    ../../Third_Lib/Middlewares/LVGL_8.3.10/GUI/lvgl/examples/porting/: lv_port_disp_template.c lv_port_indev_template.c
  group Middlewares/lvgl/src/core
    ../../Third_Lib/Middlewares/LVGL_8.3.10/GUI/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group Middlewares/lvgl/src/draw
    ../../Third_Lib/Middlewares/LVGL_8.3.10/GUI/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../../Third_Lib/Middlewares/LVGL_8.3.10/GUI/lvgl/src/draw/arm2d/: lv_gpu_arm2d.c
    ../../Third_Lib/Middlewares/LVGL_8.3.10/GUI/lvgl/src/draw/renesas/: lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c
    ../../Third_Lib/Middlewares/LVGL_8.3.10/GUI/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../../Third_Lib/Middlewares/LVGL_8.3.10/GUI/lvgl/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
  group Middlewares/lvgl/src/extra
    ../../Third_Lib/Middlewares/LVGL_8.3.10/GUI/lvgl/src/extra/: lv_extra.c
    ../../Third_Lib/Middlewares/LVGL_8.3.10/GUI/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../../Third_Lib/Middlewares/LVGL_8.3.10/GUI/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../../Third_Lib/Middlewares/LVGL_8.3.10/GUI/lvgl/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../../Third_Lib/Middlewares/LVGL_8.3.10/GUI/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../../Third_Lib/Middlewares/LVGL_8.3.10/GUI/lvgl/src/extra/others/ime/: lv_ime_pinyin.c
    ../../Third_Lib/Middlewares/LVGL_8.3.10/GUI/lvgl/src/extra/others/imgfont/: lv_imgfont.c
    ../../Third_Lib/Middlewares/LVGL_8.3.10/GUI/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../../Third_Lib/Middlewares/LVGL_8.3.10/GUI/lvgl/src/extra/others/msg/: lv_msg.c
    ../../Third_Lib/Middlewares/LVGL_8.3.10/GUI/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../../Third_Lib/Middlewares/LVGL_8.3.10/GUI/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../../Third_Lib/Middlewares/LVGL_8.3.10/GUI/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../../Third_Lib/Middlewares/LVGL_8.3.10/GUI/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../../Third_Lib/Middlewares/LVGL_8.3.10/GUI/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../../Third_Lib/Middlewares/LVGL_8.3.10/GUI/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../Third_Lib/Middlewares/LVGL_8.3.10/GUI/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../../Third_Lib/Middlewares/LVGL_8.3.10/GUI/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../../Third_Lib/Middlewares/LVGL_8.3.10/GUI/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../../Third_Lib/Middlewares/LVGL_8.3.10/GUI/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../../Third_Lib/Middlewares/LVGL_8.3.10/GUI/lvgl/src/extra/widgets/led/: lv_led.c
    ../../Third_Lib/Middlewares/LVGL_8.3.10/GUI/lvgl/src/extra/widgets/list/: lv_list.c
    ../../Third_Lib/Middlewares/LVGL_8.3.10/GUI/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../../Third_Lib/Middlewares/LVGL_8.3.10/GUI/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../../Third_Lib/Middlewares/LVGL_8.3.10/GUI/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../../Third_Lib/Middlewares/LVGL_8.3.10/GUI/lvgl/src/extra/widgets/span/: lv_span.c
    ../../Third_Lib/Middlewares/LVGL_8.3.10/GUI/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../../Third_Lib/Middlewares/LVGL_8.3.10/GUI/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../../Third_Lib/Middlewares/LVGL_8.3.10/GUI/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../../Third_Lib/Middlewares/LVGL_8.3.10/GUI/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../../Third_Lib/Middlewares/LVGL_8.3.10/GUI/lvgl/src/extra/widgets/win/: lv_win.c
  group Middlewares/lvgl/src/font
    ../../Third_Lib/Middlewares/LVGL_8.3.10/GUI/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group Middlewares/lvgl/src/gpu
    ../../Third_Lib/Middlewares/LVGL_8.3.10/GUI/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../../Third_Lib/Middlewares/LVGL_8.3.10/GUI/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
  group Middlewares/lvgl/src/hal
    ../../Third_Lib/Middlewares/LVGL_8.3.10/GUI/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group Middlewares/lvgl/src/misc
    ../../Third_Lib/Middlewares/LVGL_8.3.10/GUI/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group Middlewares/lvgl/src/widgets
    ../../Third_Lib/Middlewares/LVGL_8.3.10/GUI/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group DOC
    ../../: README.md
